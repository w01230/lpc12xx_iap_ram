# Keil uVision project lpc1227.uvprojx, settings and files
target lpc1227_ram (6060000::V6.6::.\ARMCLANG)
  device: LPC1227FBD64/301 NXP
  pack: Keil.LPC1200_DFP.1.0.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LPC1227 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin  !L
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x10000100 size 0x1000
  memory RVCT9: RAM 0x10001100 size 0x800
  group source
    ./Source/: boot_op.c crc32.c flash.c main.c
target lpc1227_rom (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1227FBD64/301 NXP
  pack: Keil.LPC1200_DFP.1.0.0
  cpu: as above
  output: LPC1227 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin  !L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, Device:Startup 1.0.0
